# Keil uVision project FreeRTOS_Semaphore_LowPower.uvprojx, settings and files
target FreeRTOS_Semaphore_LowPower (6190000::V6.19::ARMCLANG)
  device: STM32U083RCTx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: FreeRTOS_Semaphore_LowPower +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U083xx
  c include: ../Inc;../../../../../Drivers/STM32U0xx_HAL_Driver/Inc;../../../../../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/;../../../../../Drivers/CMSIS/RTOS2/Include/;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM0/
  asm include: ../Inc;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM0/
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32u083xx.s
  group Application/User
    ../Src/: main.c app_freertos.c stm32u0xx_it.c stm32u0xx_hal_msp.c stm32u0xx_hal_timebase_tim.c
  group Doc
    ../: README.md
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM0/: port.c portasm.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.6.0
