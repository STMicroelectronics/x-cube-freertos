# IAR project FreeRTOS_MPU.ewp, settings and files
configuration FreeRTOS_MPU (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../../../../../Drivers/CMSIS/RTOS2/Include/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Inc
  OBJCOPY.OOCOutputFile: FreeRTOS_MPU.hex
  ILINK.IlinkOutputFile: FreeRTOS_MPU.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User
    ../Src/: app_freertos.c main.c stm32h5xx_hal_msp.c stm32h5xx_hal_timebase_tim.c stm32h5xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
