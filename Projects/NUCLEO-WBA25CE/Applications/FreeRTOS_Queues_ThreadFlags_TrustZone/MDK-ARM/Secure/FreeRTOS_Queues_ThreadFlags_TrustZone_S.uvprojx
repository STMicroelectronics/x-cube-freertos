# Keil uVision project FreeRTOS_Queues_ThreadFlags_TrustZone_S.uvprojx, settings and files
target FreeRTOS_Queues_ThreadFlags_TrustZone_S (6210000::V6.21::ARMCLANG)
  device: STM32WBA25CEUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.6.0-B02
  cpu: IRAM(0x30000000-0x30007FFF) IROM(0x0C000000-0xC03DFFF) IROM2(0x0C03E000-0xC03FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: FreeRTOS_Queues_ThreadFlags_TrustZone_S +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WBA25xx
  c include: ../../Secure/Inc;../../Secure_nsclib;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/secure/;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include
  asm define: secureconfigMAX_SECURE_CONTEXTS=8
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x3e000
  memory RVCT5: ROM 0xc03e000 size 0x2000
  memory RVCT9: RAM 0x30000000 size 0x8000
  scatter file: stm32wba25xx_flash_s.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
--diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ../: startup_stm32wba25xx.s
  group Application/User/Secure
    ../../Secure/Src/: main.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c secure_nsc.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32wbaxx_s.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_cortex.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_icache.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Secure
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/secure/: secure_context.c secure_context_port.c secure_heap.c secure_init.c
software components: CMSIS:CORE 5.6.0
