# IAR project FreeRTOS_Semaphore_LowPower.ewp, settings and files
configuration FreeRTOS_Semaphore_LowPower (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA25CE ST STM32WBA25CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WBA25xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../../../../../Drivers/CMSIS/RTOS2/Include/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: FreeRTOS_Semaphore_LowPower.hex
  ILINK.IlinkOutputFile: FreeRTOS_Semaphore_LowPower.out
  ILINK.IlinkIcfFile: stm32wba25xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba25xx.s
  group Application/User
    ../Src/: main.c app_freertos.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c stm32wbaxx_hal_timebase_tim.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_lptim.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: portasm.s port.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
