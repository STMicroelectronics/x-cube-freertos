# IAR project FreeRTOS_Queues_ThreadFlags_TrustZone_AppliSecure.ewp, settings and files
configuration FreeRTOS_Queues_ThreadFlags_TrustZone_AppliSecure (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx
  ICCARM.CCIncludePath2: ../../AppliSecure/Inc; ../../Secure_nsclib; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM55/secure/; ../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: secureconfigMAX_SECURE_CONTEXTS=8
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: FreeRTOS_Queues_ThreadFlags_TrustZone_AppliSecure.bin
  ILINK.IlinkOutputFile: FreeRTOS_Queues_ThreadFlags_TrustZone_AppliSecure.out
  ILINK.IlinkIcfFile: stm32n657xx_LRUN.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx.s
  group Application/User/AppliSecure
    ../../AppliSecure/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c secure_nsc.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../AppliSecure/Src/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_rif.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Secure
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM55/secure/: secure_context_port_asm.s secure_context.c secure_heap.c secure_init.c
