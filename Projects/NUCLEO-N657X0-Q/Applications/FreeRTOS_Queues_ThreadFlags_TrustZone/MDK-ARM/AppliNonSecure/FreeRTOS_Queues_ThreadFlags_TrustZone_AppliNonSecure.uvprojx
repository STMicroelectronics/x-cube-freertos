# Keil uVision project FreeRTOS_Queues_ThreadFlags_TrustZone_AppliNonSecure.uvprojx, settings and files
target FreeRTOS_Queues_ThreadFlags_TrustZone_AppliNonSecure (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x24180000-0x241FFFFF) IROM(0x24100400-0x2417FFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: FreeRTOS_Queues_ThreadFlags_TrustZone_AppliNonSecure +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx, DATATYPE, NO_OTP_FUSE
  c include: ../../AppliNonSecure/Inc;../../Secure_nsclib;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM55/non_secure/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM55/secure/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/;../../../../../../Drivers/CMSIS/RTOS2/Include/;../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x24100400 size 0x7fc00
  memory RVCT9: RAM 0x24180000 size 0x80000
  scatter file: stm32n657xx_LRUN_ns.sct
  link misc: ../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32n657xx.c
  group Application/User/AppliNonSecure
    ../../AppliNonSecure/Src/: main.c app_freertos.c stm32n6xx_it.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../AppliNonSecure/Src/: system_stm32n6xx_ns.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Secure
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM55/non_secure/: port.c portasm.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Doc
    ../../: README.md
software components: CMSIS:CORE 5.6.0
