# Keil uVision project FreeRTOS_Semaphore_LowPower.uvprojx, settings and files
target FreeRTOS_Semaphore_LowPower (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000,0x40000) IRAM2(0x30000000,0x00040000) IROM(0x34180400,0x003FC00) XRAM(0x34200000,0x1C0000) XRAM2(0x38000000,0x00008000) XRAM3(0x35000000,0x01000000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOS_Semaphore_LowPower +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_FULL_ASSERT,USE_HAL_DRIVER
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure;../../../../../Drivers/CMSIS/RTOS2/Include
  asm include: ../Inc
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT6: RAM 0x34200000 size 0x1c0000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT8: RAM 0x35000000 size 0x1000000
  memory RVCT9: RAM 0x341c0000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\stm32n657xx_axisram2_fsbl.sct
  group Application/MDK-ARM
    ./: startup_stm32n657xx_fsbl.c
  group Application/User
    ../Src/: app_freertos.c main.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c stm32n6xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_lptim.c
  group Middleware/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middleware/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group Middleware/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM55_NTZ/non_secure/: port.c portasm.c
software components: CMSIS:CORE 5.6.0
