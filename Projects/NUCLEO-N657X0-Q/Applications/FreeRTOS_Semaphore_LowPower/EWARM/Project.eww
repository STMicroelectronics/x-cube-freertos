<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\FreeRTOS_Semaphore_LowPower_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
