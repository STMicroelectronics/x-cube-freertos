# IAR project FreeRTOS_Queues_ThreadFlags_TrustZone_S.ewp, settings and files
configuration FreeRTOS_Queues_ThreadFlags_TrustZone_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../Secure/Inc; ../Secure_nsclib; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33/secure/; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: secureconfigMAX_SECURE_CONTEXTS=8
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: FreeRTOS_Queues_ThreadFlags_TrustZone_S.hex
  ILINK.IlinkOutputFile: FreeRTOS_Queues_ThreadFlags_TrustZone_S.out
  ILINK.IlinkIcfFile: stm32u575xx_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User/Secure
    ../Secure/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c secure_nsc.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32u5xx_s.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_icache.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Secure
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33/secure/: secure_context_port_asm.s secure_context.c secure_heap.c secure_init.c
