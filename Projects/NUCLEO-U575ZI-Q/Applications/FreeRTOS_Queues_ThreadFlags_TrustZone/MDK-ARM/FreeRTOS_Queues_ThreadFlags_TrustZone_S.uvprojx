# Keil uVision project FreeRTOS_Queues_ThreadFlags_TrustZone_S.uvprojx, settings and files
target FreeRTOS_Queues_ThreadFlags_TrustZone_S (6210000::V6.21::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.4
  cpu: IRAM(0x30000000-0x3003FFFF) IROM(0x0C000000-0xC0FDFFF) IROM2(0x0C0FE000-0xC0FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: FreeRTOS_Queues_ThreadFlags_TrustZone_S +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ../Secure/Inc;../Secure_nsclib;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/secure/;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Include
  asm define: secureconfigMAX_SECURE_CONTEXTS=8
  asm include: ..//Secure/Inc;../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0xc000000 size 0xfe000
  memory RVCT5: ROM 0xc0fe000 size 0x2000
  memory RVCT9: RAM 0x30000000 size 0x40000
  link misc: --import_cmse_lib_out=../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Secure
    ../Secure/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c secure_nsc.c
  group Doc
    ../: README.md
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_icache.c
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32u5xx_s.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Secure
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/secure/: secure_context.c secure_context_port.c secure_heap.c secure_init.c
software components: CMSIS:CORE 5.6.0
