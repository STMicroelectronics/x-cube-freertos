# Keil uVision project FreeRTOS_Queues_ThreadFlags_TrustZone_NS.uvprojx, settings and files
target FreeRTOS_Queues_ThreadFlags_TrustZone_NS (6210000::V6.21::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.5.0-A01
  cpu: IRAM(0x20018000-0x2002FFFF) IRAM2(0x20038000-0x2003FFFF) IROM(0x08080000-0x80FFFFF)   CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: FreeRTOS_Queues_ThreadFlags_TrustZone_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U385xx
  c include: ../../NonSecure/Inc;../../Secure_nsclib;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/secure/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/;../../../../../../Drivers/CMSIS/RTOS2/Include/;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include
  asm include: ../NonSecure/Inc;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8080000 size 0x80000
  memory RVCT9: RAM 0x20018000 size 0x18000
  memory RVCT10: RAM 0x20038000 size 0x8000
  link misc: ../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32u385xx.s
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c app_freertos.c stm32u3xx_it.c stm32u3xx_hal_msp.c stm32u3xx_hal_timebase_tim.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32u3xx_ns.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Secure
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure/: port.c portasm.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_icache.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
software components: CMSIS:CORE 5.6.0
