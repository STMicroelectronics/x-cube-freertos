<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NonSecure\FreeRTOS_Queues_ThreadFlags_TrustZone_NS.ewp</path>
  </project><project>
    <path>$WS_DIR$\Secure\FreeRTOS_Queues_ThreadFlags_TrustZone_S.ewp</path>
  </project>
  <batchBuild />
</workspace>
